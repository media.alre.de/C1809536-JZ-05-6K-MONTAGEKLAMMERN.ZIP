Properties of the parts of a building model (IFC4)

# File
Description: Montage-Klammern (Kunststoff) 6 Stk., ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: C1809536, Montage-Klammern (Kunststoff) 6 Stk.
In: Raum
Description: Montage-Klammern (Kunststoff) für Frostschutzthermostat JTF/RTKSA, 6 Stk.; Classification: EC011349 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: C1809536; ModelLabel: JZ-05/6K; GlobalTradeItemNumber: 4050528018649; ProductURL: https://alre.de/produkt_C1809536
Pset_Specification - NominalLength: 0.051 m; NominalWidth: 0.0505 m; NominalDepth: 0.011 m; NetWeight: 0.05
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: sonstige; Zubehör: yes; ETIM-Klasse: EC011349; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-C1809536.pdf
